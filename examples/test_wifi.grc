options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: test_wifi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    domain: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    domain: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    domain: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: fft_fft_0
  id: fft_fft
  parameters:
    T: complex
    direction: 'True'
    domain: cpu
    fft_size: '64'
    shift: 'False'
    showports: 'False'
    window: '0'
  states: {}
- name: fileio_file_source_0
  id: fileio_file_source
  parameters:
    domain: cpu
    filename: '''/data/data/wifi_capt_2462_20MHz.fc32'''
    itemsize: '8'
    len: '0'
    offset: '0'
    repeat: 'False'
    showports: 'False'
  states: {}
- name: qtgui_time_sink_0
  id: qtgui_time_sink
  parameters:
    T: float
    domain: cpu
    name: '''1'''
    nconnections: '1'
    samp_rate: '1'
    showports: 'False'
    size: '1024'
  states: {}
- name: qtgui_time_sink_0_0
  id: qtgui_time_sink
  parameters:
    T: complex
    domain: cpu
    name: '''2'''
    nconnections: '1'
    samp_rate: '1'
    showports: 'False'
    size: '1024'
  states: {state: disabled}
- name: qtgui_time_sink_0_1
  id: qtgui_time_sink
  parameters:
    T: float
    domain: cpu
    name: '''3'''
    nconnections: '1'
    samp_rate: '1'
    showports: 'False'
    size: '1024'
  states: {state: disabled}
- name: wifi_frame_equalizer_0
  id: wifi_frame_equalizer
  parameters:
    algo: ''
    bw: ''
    domain: cpu
    freq: ''
    showports: 'False'
  states: {}
- name: wifi_pre_sync_0
  id: wifi_pre_sync
  parameters:
    buffer_size: '65536'
    domain: cuda
    showports: 'False'
    window_size: '48'
  states: {}
- name: wifi_sync_long_0
  id: wifi_sync_long
  parameters:
    domain: cuda
    showports: 'False'
    sync_length: sync_length
  states: {}
- name: wifi_sync_short_0
  id: wifi_sync_short
  parameters:
    domain: cuda
    min_plateau: '2'
    showports: 'False'
    threshold: '.56'
  states: {}

connections:
- [fft_fft_0, '0', wifi_frame_equalizer_0, '0']
- [fileio_file_source_0, '0', wifi_pre_sync_0, '0']
- [wifi_pre_sync_0, '0', blocks_null_sink_0, '0']
- [wifi_pre_sync_0, '0', wifi_sync_short_0, '0']
- [wifi_pre_sync_0, '1', blocks_null_sink_0_0, '0']
- [wifi_pre_sync_0, '1', qtgui_time_sink_0_0, '0']
- [wifi_pre_sync_0, '1', wifi_sync_short_0, '1']
- [wifi_pre_sync_0, '2', blocks_null_sink_0_0_0, '0']
- [wifi_pre_sync_0, '2', qtgui_time_sink_0_1, '0']
- [wifi_pre_sync_0, '2', wifi_sync_short_0, '2']
- [wifi_sync_long_0, '0', fft_fft_0, '0']
- [wifi_sync_short_0, '0', wifi_sync_long_0, '0']

metadata:
  file_format: 1

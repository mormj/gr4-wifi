options:
  parameters:
    author: josh
    generate_options: no_gui
    id: test_wifi
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    domain: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    domain: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    domain: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: dbg
  id: blocks_message_debug
  parameters:
    domain: cpu
    en_uvec: 'False'
    showports: 'False'
  states: {}
- name: decode
  id: wifi_decode_packetized
  parameters:
    debug: 'False'
    domain: cpu
    log: 'False'
    showports: 'False'
  states: {}
- name: fft_fft_0
  id: fft_fft
  parameters:
    T: complex
    direction: 'True'
    domain: cuda
    fft_size: '64'
    shift: 'True'
    showports: 'False'
    window: np.ones(64)
  states: {}
- name: fileio_file_source_0
  id: fileio_file_source
  parameters:
    domain: cpu
    filename: '''/data/data/cropcircles/wifi_synth_1500_1kpad_20MHz_10s_MCS0.fc32'''
    itemsize: '8'
    len: '0'
    offset: '0'
    repeat: 'False'
    showports: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_0
  id: qtgui_time_sink
  parameters:
    T: float
    domain: cpu
    name: '''1'''
    nconnections: '1'
    samp_rate: '1'
    showports: 'False'
    size: '1024'
  states: {state: disabled}
- name: qtgui_time_sink_0_0
  id: qtgui_time_sink
  parameters:
    T: complex
    domain: cpu
    name: '''2'''
    nconnections: '1'
    samp_rate: '1'
    showports: 'False'
    size: '1024'
  states: {state: disabled}
- name: qtgui_time_sink_0_1
  id: qtgui_time_sink
  parameters:
    T: float
    domain: cpu
    name: '''3'''
    nconnections: '1'
    samp_rate: '1'
    showports: 'False'
    size: '1024'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      end = time.time()
      elapsed = end - self.startt
      #print(f"Received: {self.dbg.num_messages()} in {elapsed} seconds")
      print(f"Received: {self.dbg.num_messages()} in {elapsed} seconds")
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: self.startt = time.time()
    section: main_after_init
  states: {}
- name: streamops_head_0
  id: streamops_head
  parameters:
    domain: cpu
    itemsize: '0'
    nitems: '25000000'
    showports: 'False'
  states: {state: disabled}
- name: wifi_frame_equalizer_0
  id: wifi_frame_equalizer
  parameters:
    algo: ''
    bw: ''
    debug: 'False'
    domain: cpu
    freq: ''
    log: 'False'
    showports: 'False'
  states: {state: disabled}
- name: wifi_packetize_frame_0
  id: wifi_packetize_frame
  parameters:
    algo: '0'
    bw: 20e6
    debug: 'False'
    domain: cpu
    freq: 2462e6
    log: 'False'
    showports: 'False'
  states: {}
- name: wifi_pre_sync_0
  id: wifi_pre_sync
  parameters:
    buffer_size: '65536'
    debug: 'False'
    domain: cuda
    log: 'False'
    showports: 'False'
    window_size: '48'
  states: {}
- name: wifi_sync_long_0
  id: wifi_sync_long
  parameters:
    debug: 'False'
    domain: cuda
    log: 'False'
    showports: 'False'
    sync_length: sync_length
  states: {}
- name: wifi_sync_short_0
  id: wifi_sync_short
  parameters:
    debug: 'False'
    domain: cuda
    log: 'False'
    min_plateau: '2'
    showports: 'False'
    threshold: '.56'
  states: {}

connections:
- [decode, out, dbg, store]
- [fft_fft_0, '0', wifi_frame_equalizer_0, '0']
- [fft_fft_0, '0', wifi_packetize_frame_0, '0']
- [fileio_file_source_0, '0', streamops_head_0, '0']
- [fileio_file_source_0, '0', wifi_pre_sync_0, '0']
- [streamops_head_0, '0', wifi_pre_sync_0, '0']
- [wifi_packetize_frame_0, pdus, decode, pdus]
- [wifi_pre_sync_0, '0', blocks_null_sink_0, '0']
- [wifi_pre_sync_0, '0', wifi_sync_short_0, '0']
- [wifi_pre_sync_0, '1', blocks_null_sink_0_0, '0']
- [wifi_pre_sync_0, '1', qtgui_time_sink_0_0, '0']
- [wifi_pre_sync_0, '1', wifi_sync_short_0, '1']
- [wifi_pre_sync_0, '2', blocks_null_sink_0_0_0, '0']
- [wifi_pre_sync_0, '2', qtgui_time_sink_0_1, '0']
- [wifi_pre_sync_0, '2', wifi_sync_short_0, '2']
- [wifi_sync_long_0, '0', fft_fft_0, '0']
- [wifi_sync_short_0, '0', wifi_sync_long_0, '0']

metadata:
  file_format: 1
